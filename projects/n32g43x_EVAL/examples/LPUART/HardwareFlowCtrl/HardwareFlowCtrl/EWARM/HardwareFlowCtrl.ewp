# IAR project HardwareFlowCtrl.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G435RB Nations N32G435RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G43X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ../inc; ../../../../../../../firmware/CMSIS/core; ../../../../../../../firmware/CMSIS/device; ../../../../../../../firmware/n32g43x_std_periph_driver/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HardwareFlowCtrl.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration N32G43x (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: pa084
  OBJCOPY.OOCOutputFile: HardwareFlowCtrl.bin
  group CMSIS
    ../../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_gpio.c n32g43x_lpuart.c n32g43x_rcc.c n32g43x_usart.c
  group STARTUP
    ../../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x_EWARM.s
  group USER
    ../src/: main.c n32g43x_it.c
