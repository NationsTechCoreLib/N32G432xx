# IAR project IIC_DEVICE_REGISTER.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32L436MB Nations N32L436MB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G43X; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32g43x_std_periph_driver\inc; ..\..\..\..\..\..\middlewares\rt-thread\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\i2c; ..\..\DeviceDrivers\gpio\inc; ..\..\DeviceDrivers\uart\inc; ..\..\DeviceDrivers\i2c\inc; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MessageQueue.bin
  ILINK.IlinkOutputFile: IIC_DEVICE_REGISTER.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_iar.S cpuport.c
  group Device_Drivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/i2c/src/: drv_i2c.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group DOC
    ../: readme.txt
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../../../../middlewares/rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
  group FWLB
    ../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_dma.c n32g43x_exti.c n32g43x_gpio.c n32g43x_i2c.c n32g43x_rcc.c n32g43x_usart.c
  group RT-Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x_EWARM.s
  group USER
    ../src/: board.c i2c_eeprom.c main.c n32g43x_it.c
