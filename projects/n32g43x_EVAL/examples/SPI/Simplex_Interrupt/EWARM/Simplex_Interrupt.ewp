# IAR project Simplex_Interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G435RB Nations N32G435RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G43X; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\bsp; ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\firmware\n32G43x_std_periph_driver\inc; ..\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Simplex_Interrupt.bin
  ILINK.IlinkOutputFile: Simplex_Interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32g43x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32g43x_std_periph_driver/src/: misc.c n32g43x_exti.c n32g43x_gpio.c n32g43x_rcc.c n32g43x_spi.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32g43x_EWARM.s
  group USER
    ../src/: main.c n32g43x_it.c
